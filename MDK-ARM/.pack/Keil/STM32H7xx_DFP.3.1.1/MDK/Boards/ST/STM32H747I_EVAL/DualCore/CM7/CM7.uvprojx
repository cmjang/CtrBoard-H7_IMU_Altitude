# Keil uVision project CM7.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CM7
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\;..\Common;..\Common\STM32H747I_EVAL_BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h747_cm7.sct
  link misc: --any_placement=first_fit
  group Source Files
    ./: DualCore.c
  group Documentation
    ../: Abstract.txt
  group :STM32CubeMX_CM7:Common Sources
    ../STM32CubeMX/STCubeGenerated/CM7/Src/: main.c stm32h7xx_it.c
    ../STM32CubeMX/STCubeGenerated/CM7/Inc/: stm32h7xx_it.h
  group BSP
    ../Common/STM32H747I_EVAL_BSP/: stm32h747i_eval.c
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL:ADC 1.11.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:Flash 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:HSEM 1.11.0, Device:STM32Cube HAL:I2C 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:Startup 1.11.0
