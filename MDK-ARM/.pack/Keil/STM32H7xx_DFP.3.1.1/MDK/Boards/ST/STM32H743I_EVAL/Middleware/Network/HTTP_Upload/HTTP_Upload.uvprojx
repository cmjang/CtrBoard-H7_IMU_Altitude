# Keil uVision project HTTP_Upload.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: HTTP_Upload
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MemoryCard_CD0_Pin_Extern
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743.sct
  link misc: --any_placement=first_fit
  group Source
    ./: HTTP_Upload.c HTTP_Server_CGI.c
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc home.png keil.gif logo.gif llblue.jpg pabb.gif upload.cgi dir.cgi format.cgi
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
target Release (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: as above
  output: HTTP_Upload
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MemoryCard_CD0_Pin_Extern
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743.sct
  link misc: --diag_suppress=L6314
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:File 1.2.0, Compiler:I/O:TTY 1.2.0, File System:CORE 6.15.3, File System:CORE 6.15.3, File System:Drive:Memory Card 6.15.3, Network:CORE 7.18.0, Network:CORE 7.18.0, Network:Interface:ETH 7.18.0, Network:Service:Web Server 7.18.0, Network:Socket:TCP 7.18.0, Network:Socket:UDP 7.18.0, Board Support:Drivers:BUS 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Graphic LCD 1.1.0, Board Support:LED 1.1.0, CMSIS Driver:Ethernet MAC 1.5.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:MCI 1.7.0, Device:STM32Cube HAL:ADC 1.11.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:ETH 1.11.0, Device:STM32Cube HAL:EXTI 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:I2C 1.11.0, Device:STM32Cube HAL:LTDC 1.11.0, Device:STM32Cube HAL:MDMA 1.11.0, Device:STM32Cube HAL:MMC 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:SD 1.11.0, Device:STM32Cube HAL:SDRAM 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:Startup 1.11.0
