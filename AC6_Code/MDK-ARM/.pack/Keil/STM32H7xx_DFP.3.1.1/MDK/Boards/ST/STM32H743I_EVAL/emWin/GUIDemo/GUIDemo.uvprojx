# Keil uVision project GUIDemo.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743.sct
  link misc: --any_placement=first_fit
  group Source
    ./: GUIDemo.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
target Release (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1-dev1
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743.sct
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Board Support:Drivers:BUS 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Drivers:Touch Screen 1.1.0, Board Support:Joystick 1.1.0, Board Support:Touchscreen 1.1.0, Board Support:emWin LCD 1.1.0, Device:STM32Cube HAL:ADC 1.11.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:DMA2D 1.11.0, Device:STM32Cube HAL:EXTI 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:I2C 1.11.0, Device:STM32Cube HAL:LTDC 1.11.0, Device:STM32Cube HAL:MDMA 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:SDRAM 1.11.0, Device:STM32Cube HAL:TIM 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:Startup 1.11.0, Graphics Display:STM32H743I-EVAL 1.0.3, Graphics:CORE 6.32.3, Graphics:Demo:AntialiasedText 6.32.3, Graphics:Demo:Automotive 6.32.3, Graphics:Demo:BarGraph 6.32.3, Graphics:Demo:Bitmap 6.32.3, Graphics:Demo:ColorBar 6.32.3, Graphics:Demo:Cursor 6.32.3, Graphics:Demo:Fading 6.32.3, Graphics:Demo:Framework 6.32.3, Graphics:Demo:Graph 6.32.3, Graphics:Demo:IconView 6.32.3, Graphics:Demo:ImageFlow 6.32.3, Graphics:Demo:ListView 6.32.3, Graphics:Demo:RadialMenu 6.32.3, Graphics:Demo:Skinning 6.32.3, Graphics:Demo:Speed 6.32.3, Graphics:Demo:TransparentDialog 6.32.3, Graphics:Demo:Treeview 6.32.3, Graphics:Demo:VScreen 6.32.3, Graphics:Demo:WashingMachine 6.32.3, Graphics:Input Device:Joystick 6.32.3, Graphics:Input Device:Touchscreen 6.32.3
