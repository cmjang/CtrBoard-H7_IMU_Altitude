# Keil uVision project STM32H7xx.uvproj, settings and files
target STM32H7xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7_CM4 STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32H7x_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM STM32H776xx CORE_CM7
  c include: ./;..\..\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
