# Keil uVision project STM32H7xx_CM7.uvprojx, settings and files
target STM32H7xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: STM32H7xx_CM7
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM CORE_CM7 STM32F4XX=<ioCC1110.h> USE_STDPERIPH_DRIVER
  c include: ./;..\..\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\CMSIS\Include;.\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
