# Keil uVision project STM32H723x.uvprojx, settings and files
target STM32H723xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: STM32H723x_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM STM32H743xx CORE_CM7,STM32H723xx
  c include: ./;..\..\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32H730xx_128K (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32H730xx_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1
  c define: FLASH_MEM STM32H743xx CORE_CM7,STM32H730xx_128
  c include: ./;..\..\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
