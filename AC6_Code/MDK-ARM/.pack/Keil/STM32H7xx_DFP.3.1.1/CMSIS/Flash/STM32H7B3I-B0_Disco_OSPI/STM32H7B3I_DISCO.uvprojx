# Keil uVision project STM32H7B3I_DISCO.uvprojx, settings and files
target STM32H7B3I_Disco_OSPI (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: MX25LM51245G_STM32H7B3I-Disco
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32H7B3xxQ,USE_IOEXPANDER, CORE_CM7,STM32H7B3
  c include: ./;.\OSPI;..\..\..\Drivers\BSP\Components;..\..\..\Drivers\CMSIS\Core\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32H7B3I-DK
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group OSPI
    ./OSPI/: STM32H7OSPI.c stm32h7b3i_discovery_ospi.c
    ../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rcc.c
    ../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
target STM32H7B0_Disco_OSPI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: MX25LM51245G_STM32H7B0-Disco
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32H7B0xxQ,USE_IOEXPANDER, CORE_CM7,STM32H7B0
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.4.0
